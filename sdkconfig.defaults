## sdkconfig.defaults
```kconfig
# Load
CONFIG_ESPTOOLPY_PORT="COM4"
CONFIG_ESPTOOLPY_BAUD_921600B=y

# mDNs
CONFIG_ENABLE_MDNS=y

# IPV6
CONFIG_LWIP_IPV6=y
```
